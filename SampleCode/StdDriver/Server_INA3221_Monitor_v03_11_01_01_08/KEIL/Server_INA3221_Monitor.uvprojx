# Keil uVision project Server_INA3221_Monitor.uvprojx, settings and files
target Server_INA3221_Monitor (6220000::V6.22::ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x2a000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: Server_INA3221_Monitor_03_11_01_01_08
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: .\FILESUM .\obj\@L.bin .\obj\@L_SUM.bin"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\StdDriver\inc;..\Platform;..\LED;..\USB;..\Flash;..\I2C;..\Monitor;..\EEPROM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  scatter file: Server_INA3221_Monitor.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --pad=0xFF
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c gpio.c timer.c i2c.c usci_i2c.c uart.c rmc.c
  group Flash
    ../Flash/: Flash.c
  group I2C
    ../I2C/: I2C_Control.c
  group Monitor
    ../Monitor/: Monitor_Control.c
  group EEPROM
    ../EEPROM/: EEPROM_FRU_Table.c
    ./: EEPROM_COMPANY_INF.c
